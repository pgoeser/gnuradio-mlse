<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>gsm_vectorize</value></param>
<param><key>description</key><value>takes gsm samples (symbolrate), derotates them, presents everything but the guard interval as a vector</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>Modulators</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>148</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>mlse_derotate_cc</key>
<param><key>id</key><value>mlse_derotate_cc_0</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>samples_per_rot</key><value>4</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>148+8</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>mlse_vector_slice_vv</key>
<param><key>id</key><value>mlse_vector_slice_vv_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>input_length</key><value>156</value></param>
<param><key>output_offset</key><value>0</value></param>
<param><key>output_length</key><value>148</value></param>
<param><key>reverse</key><value>False</value></param>
</block>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>mlse_derotate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_derotate_cc_0</source_block_id><sink_block_id>gr_stream_to_vector_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_1</source_block_id><sink_block_id>mlse_vector_slice_vv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_vector_slice_vv_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
