<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>mlse_lut_bxv</key>
<param><key>id</key><value>mlse_lut_bxv_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>data</key><value>[[0,1],[2,0],[3,0]]</value></param>
</block>
<block>
<key>gr_vector_sink_x</key>
<param><key>id</key><value>gr_vector_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>gr_vector_sink_x</key>
<param><key>id</key><value>gr_vector_sink_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>5</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>0, 1, 0</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>0, 0</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>mlse_viterbi_vcb</key>
<param><key>id</key><value>mlse_viterbi_vcb_0</value></param>
<param><key>data_length</key><value>3</value></param>
<param><key>channel_length</key><value>2</value></param>
<param><key>tailsymbols</key><value>1</value></param>
<param><key>modulation_table</key><value>1,-1</value></param>
</block>
<block>
<key>gr_vector_sink_x</key>
<param><key>id</key><value>gr_vector_sink_x_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vector</key><value>0, 0, 0</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>3</value></param>
</block>
<block>
<key>mlse_vector_concat_vv</key>
<param><key>id</key><value>mlse_vector_concat_vv_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size1</key><value>3</value></param>
<param><key>size2</key><value>2</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>0, 1, 0</value></param>
<param><key>repeat</key><value>False</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>mlse_lut_bxv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_lut_bxv_0</source_block_id><sink_block_id>gr_vector_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_viterbi_vcb_0</source_block_id><sink_block_id>gr_vector_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0</source_block_id><sink_block_id>mlse_viterbi_vcb_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>mlse_vector_concat_vv_0</source_block_id><sink_block_id>mlse_viterbi_vcb_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_1</source_block_id><sink_block_id>mlse_viterbi_vcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_vector_concat_vv_0</source_block_id><sink_block_id>gr_vector_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_1</source_block_id><sink_block_id>mlse_vector_concat_vv_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_2</source_block_id><sink_block_id>mlse_vector_concat_vv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
