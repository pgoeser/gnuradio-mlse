<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>testapp_grc</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1733</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_taps</value></param>
<param><key>value</key><value>[1,0,0,0,0]</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>simu_length</value></param>
<param><key>value</key><value>2000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise_amplitude</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gsm_vectorize</key>
<param><key>id</key><value>gsm_vectorize_0</value></param>
</block>
<block>
<key>mlse_randint_bxv</key>
<param><key>id</key><value>mlse_randint_bxv_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>range</key><value>8</value></param>
</block>
<block>
<key>gsm_modulate_burst</key>
<param><key>id</key><value>gsm_modulate_burst_0</value></param>
<param><key>samples_per_symbol</key><value>8</value></param>
</block>
<block>
<key>testchannel</key>
<param><key>id</key><value>testchannel_0</value></param>
<param><key>noise_amplitude</key><value>noise_amplitude</value></param>
<param><key>filter_taps</key><value>filter_taps</value></param>
<param><key>channel_taps</key><value>channel_taps</value></param>
<param><key>delay</key><value>channel_delay</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel_taps</value></param>
<param><key>value</key><value>[1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>channel_delay</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>mlse_vector_slice_vv</key>
<param><key>id</key><value>mlse_vector_slice_vv_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>input_length</key><value>116</value></param>
<param><key>output_offset</key><value>2</value></param>
<param><key>output_length</key><value>112</value></param>
<param><key>reverse</key><value>False</value></param>
</block>
<block>
<key>mlse_equalizer_midamble_vcb</key>
<param><key>id</key><value>mlse_equalizer_midamble_vcb_1</value></param>
</block>
<block>
<key>mlse_vector_slice_vv</key>
<param><key>id</key><value>mlse_vector_slice_vv_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>input_length</key><value>116</value></param>
<param><key>output_offset</key><value>2</value></param>
<param><key>output_length</key><value>112</value></param>
<param><key>reverse</key><value>False</value></param>
</block>
<block>
<key>mlse_ber_vbi</key>
<param><key>id</key><value>mlse_ber_vbi_0</value></param>
<param><key>length</key><value>112</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>simu_length</value></param>
<param><key>vlen</key><value>148</value></param>
</block>
<block>
<key>mlse_randint_bxv</key>
<param><key>id</key><value>mlse_randint_bxv_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>range</key><value>2</value></param>
</block>
<block>
<key>gr_head</key>
<param><key>id</key><value>gr_head_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>(simu_length+1)*116</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_stream_to_vector</key>
<param><key>id</key><value>gr_stream_to_vector_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>116</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<connection><source_block_id>mlse_equalizer_midamble_vcb_1</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_ber_vbi_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>gsm_modulate_burst_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>testchannel_0</source_block_id><sink_block_id>gsm_vectorize_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_randint_bxv_1</source_block_id><sink_block_id>gsm_modulate_burst_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mlse_randint_bxv_1</source_block_id><sink_block_id>mlse_equalizer_midamble_vcb_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gsm_vectorize_0</source_block_id><sink_block_id>gr_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0</source_block_id><sink_block_id>mlse_equalizer_midamble_vcb_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gsm_modulate_burst_0</source_block_id><sink_block_id>testchannel_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_stream_to_vector_0</source_block_id><sink_block_id>mlse_vector_slice_vv_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_vector_slice_vv_0</source_block_id><sink_block_id>mlse_ber_vbi_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>mlse_equalizer_midamble_vcb_1</source_block_id><sink_block_id>mlse_vector_slice_vv_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_vector_slice_vv_0_0</source_block_id><sink_block_id>mlse_ber_vbi_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>mlse_randint_bxv_0</source_block_id><sink_block_id>gr_head_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_head_0_0</source_block_id><sink_block_id>gr_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
